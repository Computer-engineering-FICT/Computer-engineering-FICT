SEL RB1
MOV R0, #00h
MOV R7, #07h
INPUT:
	INS A, BUS
	MOV @R0, A
	INC R0
	DJNZ R7, INPUT

SEL RB0
INS A, BUS
MOV R7, A

MOV A, R2
ADD A, R3
MOV R1, A

LOOP:
	MOV A, R2
	DEC A
	RL A
	RL A
	ANL A, #11111100b
	MOV R4, A
	JC C_IS1
	CALL MPP
	C_IS1:
	MOV A, R4
	CPL A
	INC A
	ADD A, R1
	DEC A
	MOV R7, A
	DJNZ R7, LOOP

MOV A, R2
XRL A, R7
MOV A, R6

MOV A, R6
ADD A, R0
INC A
MOV R1, A

MPP:
	MOV A, R1
	DEC A
	MOV R5, A
	IF2:
		MOV A, R1
		XRL A, R4
		CPL A
		MOV R0, A
		JF0 IF2
	MOV A, R0
	CPL A
	INC A
	ADD A, R5
	RR A
	ANL A, #01111111b
	RET

END